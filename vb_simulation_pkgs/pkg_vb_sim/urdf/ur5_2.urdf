Commit message: task3 solution

File: vb_simulation_pkgs/pkg_vb_sim/urdf/ur5_2.urdf (robot description, URDF)
Before this commit: robot ur5, 14 links, 13 joints
Links:
- removed link world
- added link ur5_origin
Joints:
- joint ur5_pedestal_joint: parent world -> ur5_origin
